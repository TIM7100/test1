# Keil uVision project Project.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/Project.bin ./Objects/Project.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\Device\other;..\Core_Drivers\HAL_Driver;..\Source_Code\APP;..\Source_Code\BSP_Driver;..\Source_Code\IC_Driver;..\..\..\Core_Drivers\CMSIS;..\..\..\Core_Drivers\Device;..\..\..\Core_Drivers\HAL_Driver\Inc;..\..\..\Core_Drivers\ALG_Driver\Inc;..\Core_Drivers\CMSIS;.\Objects;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Src;..\Core_Drivers\HAL_Driver\Inc;..\Source_Code\user;..\Source_Code\APP;..\Core_Drivers\Device
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x20000 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group CoreDriver/CMSIS
    ../Core_Drivers/CMSIS/: core_cm33.h
  group CoreDriver/Device
    ../Core_Drivers/Device/: Startup_ACM32FP.s System_Accelerate.lib System_ACM32FP.c
  group CoreDriver/HAL
    ../Core_Drivers/HAL_Driver/Src/: HAL_AES_20210325.lib HAL_DMA.c HAL_EFlash.c HAL_EFlash_EX.lib HAL_GPIO.c HAL_HRNG_20210325.lib HAL_UART.c HAL_ADC.c HAL_CRC.c HAL_DAC.c HAL_EXTI.c HAL_FSUSB.c HAL_I2C.c HAL_I2S.c HAL_IWDT.c HAL_LPUART.c HAL_RTC.c HAL_SPI.c HAL_TIMER.c HAL_TIMER_EX.c HAL_UART_EX.c HAL_WDT.c
  group SourceCode/APP
    ../Source_Code/APP/: app.c bsp_spi.c bsp_sdcard.c crc.c aes_app.c BurnSD.c
  group SourceCode/main
    ../Source_Code/user/: main.c
