#include "aes.h"

/* ---- S-box  ---- */
static const u8 sbox[256] = {
0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

static const u8 inv_sbox[256] = {
0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d
};

/* GF(2^8) 乘2 */
static u8 xtime(u8 x)
{
    return (u8)((x << 1) ^ ((x & 0x80) ? 0x1B : 0x00));
}

/* GF(2^8) 乘法(通用) */
static u8 gf_mul(u8 x, u8 y)
{
    u8 r = 0;
    while (y)
    {
        if (y & 1) r ^= x;
        x = xtime(x);
        y >>= 1;
    }
    return r;
}

/* ===== InvMixColumns 查表(系数 9/11/13/14 的 GF 乘法结果) =====
 * 原来 InvMixColumns 每列 16 次 gf_mul,每次 gf_mul 又要跑最多 8 轮循环,
 * 是 AES 解密的性能瓶颈。这里预计算 4 张 256 字节表,把每列变成 4 次查表 + 4 次异或。
 */
static u8 gf_mul9[256];
static u8 gf_mul11[256];
static u8 gf_mul13[256];
static u8 gf_mul14[256];
static u8 gf_tables_ready = 0;

static void init_gf_tables(void)
{
    u32 i;
    for (i = 0; i < 256; i++)
    {
        u8 v = (u8)i;
        gf_mul9[i]  = gf_mul(v, 9);
        gf_mul11[i] = gf_mul(v, 11);
        gf_mul13[i] = gf_mul(v, 13);
        gf_mul14[i] = gf_mul(v, 14);
    }
    gf_tables_ready = 1;
}

/* 密钥扩展: 16字节Key -> 44个字(176字节) */
static void KeyExpansion(const u8* Key, u32* w)
{
    u32 i, temp;
    u8  rcon = 0x01;

    for (i = 0; i < 4; i++)
    {
        w[i] = ((u32)Key[4*i] << 24) | ((u32)Key[4*i+1] << 16) |
               ((u32)Key[4*i+2] << 8) | (u32)Key[4*i+3];
    }
    for (i = 4; i < 44; i++)
    {
        temp = w[i-1];
        if ((i % 4) == 0)
        {
            temp = (temp << 8) | (temp >> 24);          /* RotWord */
            temp = ((u32)sbox[(temp >> 24) & 0xFF] << 24) |   /* SubWord */
                   ((u32)sbox[(temp >> 16) & 0xFF] << 16) |
                   ((u32)sbox[(temp >> 8) & 0xFF] << 8) |
                   ((u32)sbox[temp & 0xFF]);
            temp ^= (u32)rcon << 24;                     /* Rcon */
            rcon = (u8)((rcon << 1) ^ ((rcon & 0x80) ? 0x1B : 0x00));
        }
        w[i] = w[i-4] ^ temp;
    }
}

/* 逆向行移位(解密) */
static void InvShiftRows(u8* s)
{
    u8 t;
    t = s[13]; s[13] = s[9]; s[9] = s[5]; s[5] = s[1]; s[1] = t;
    t = s[2];  s[2]  = s[10]; s[10] = t;
    t = s[6];  s[6]  = s[14]; s[14] = t;
    t = s[3];  s[3]  = s[7];  s[7]  = s[11]; s[11] = s[15]; s[15] = t;
}

/* S盒替换(逆字节代换) */
static void InvSubBytes(u8* s)
{
    u8 i;
    for (i = 0; i < 16; i++) s[i] = inv_sbox[s[i]];
}

/* 加轮密钥 */
static void AddRoundKey(u8* s, const u32* w)
{
    u8 c;
    for (c = 0; c < 4; c++)
    {
        u32 wk = w[c];
        s[4*c+0] ^= (u8)(wk >> 24);
        s[4*c+1] ^= (u8)(wk >> 16);
        s[4*c+2] ^= (u8)(wk >> 8);
        s[4*c+3] ^= (u8)wk;
    }
}

/* 逆向列混合 */
static void InvMixColumns(u8* s)
{
    u8 c;
    for (c = 0; c < 4; c++)
    {
        u8* col = &s[4*c];
        u8 a0 = col[0], a1 = col[1], a2 = col[2], a3 = col[3];
        col[0] = gf_mul14[a0] ^ gf_mul11[a1] ^ gf_mul13[a2] ^ gf_mul9[a3];
        col[1] = gf_mul9[a0]  ^ gf_mul14[a1] ^ gf_mul11[a2] ^ gf_mul13[a3];
        col[2] = gf_mul13[a0] ^ gf_mul9[a1]  ^ gf_mul14[a2] ^ gf_mul11[a3];
        col[3] = gf_mul11[a0] ^ gf_mul13[a1] ^ gf_mul9[a2]  ^ gf_mul14[a3];
    }
}

/* AES-128-CBC 解密,len必须为16的整数倍 */
void AES128_CBC_Decrypt(u8* pOut, const u8* pIn, u32 len, const u8* Key, const u8* IV)
{
    u32 w[44];
    u8  state[16], prevCipher[16], tmpCipher[16];
    u32 round;
    u32 i;
    u8  j;

    if ((len == 0) || (len % 16)) return;

    if (!gf_tables_ready)
    {
        init_gf_tables();
    }

    KeyExpansion(Key, w);
    for (j = 0; j < 16; j++) prevCipher[j] = IV[j];

    for (i = 0; i < len; i += 16)
    {
        for (j = 0; j < 16; j++)
        {
            state[j]     = pIn[i+j];
            tmpCipher[j] = pIn[i+j];   /* 保存当前密文块,作为下一轮CBC的IV */
        }

        AddRoundKey(state, &w[40]);
        for (round = 9; round >= 1; round--)
        {
            InvShiftRows(state);
            InvSubBytes(state);
            AddRoundKey(state, &w[round*4]);
            InvMixColumns(state);
        }
        InvShiftRows(state);
        InvSubBytes(state);
        AddRoundKey(state, &w[0]);

        for (j = 0; j < 16; j++)
        {
            pOut[i+j] = state[j] ^ prevCipher[j];  /* CBC异或 */
        }
        for (j = 0; j < 16; j++) prevCipher[j] = tmpCipher[j];
    }
}

/* 解密 + PKCS7去除填充,返回实际长度 */
u32 AES128_CBC_Decrypt_PKCS7(u8* pOut, const u8* pIn, u32 len, const u8* Key, const u8* IV)
{
    u32 pad;
    u32 i;

    if ((len == 0) || (len % 16)) return 0;
    AES128_CBC_Decrypt(pOut, pIn, len, Key, IV);

    pad = pOut[len-1];
    if ((pad == 0) || (pad > 16)) return len;   /* 填充值非法 */
    for (i = 0; i < pad; i++)
    {
        if (pOut[len-1-i] != pad) return len;   /* 填充不一致,非PKCS7 */
    }
    return len - pad;
}


