# Keil uVision project ACH512.uvproj, settings and files
target project (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ACH512 +hex
  c flags: Optim=1 oTime=1
  c include: .\ACH512\driver;.\ACH512\system;.\APP;.\CMSIS\Include;.\COMMON
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000040 size 0x1ffc0
  group system
    ./ACH512/system/: startup.s system_ach512.c
  group driver
    ./ACH512/driver/: uart.c sha1_20170308.lib sha256_20170308.lib sha384_20170308.lib sm3_20170308.lib
  group common
    ./COMMON/: common.c
  group app
    ./APP/: app.c main.c
  group doc
    ./: Abstratct.txt
