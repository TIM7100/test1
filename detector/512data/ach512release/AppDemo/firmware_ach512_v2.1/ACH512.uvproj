# Keil uVision project ACH512.uvproj, settings and files
target project (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ACH512 +hex
  c include: .\ACH512\driver;.\ACH512\system;.\APP;.\CMSIS\Include;.\COMMON;.\APP\sm1;.\APP\sm4;.\APP\ssf33;.\APP\aes;.\APP\des;.\APP\sm2;.\APP\sm3;.\APP\rsa;.\APP\hrng;.\APP\iso7816
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000040 size 0xffc0
  group system
    ./ACH512/system/: startup.s system_ach512.c
  group driver
    ./ACH512/driver/: uart.c usb.c usb_app.c usb_desc.c eflash.c iso7816ms.c gpio.c sm1_20170420.lib sm4_20170420.lib ssf33_20170809.lib aes_20170420.lib des_2017_0420.lib sm2sm3_20170406.lib sm3_20170308.lib rsa_20170406.lib ecdsa_20170406.lib pki_20170406.lib hrng_20170804.lib
  group common
    ./COMMON/: common.c
  group app
    ./APP/: main.c scsi.c app.c
    ./APP/sm1/: sm1_app.c
    ./APP/sm4/: sm4_app.c
    ./APP/ssf33/: ssf33_app.c
    ./APP/aes/: aes_app.c
    ./APP/des/: des_app.c
    ./APP/sm2/: sm2_app.c
    ./APP/sm3/: sm3_app.c
    ./APP/rsa/: rsa_app.c
    ./APP/hrng/: hrng_app.c
    ./APP/iso7816/: iso7816_app.c
  group doc
    ./: Abstratct.txt
