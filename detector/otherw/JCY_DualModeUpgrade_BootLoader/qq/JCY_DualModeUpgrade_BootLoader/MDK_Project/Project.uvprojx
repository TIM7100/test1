# Keil uVision project Project.uvprojx, settings and files
target Project (6210000::V6.21::ARMCLANG)
  device: ACM32FP401RKU6 Aisinochip
  pack: Aisinochip.ACM32FP4.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) IROM2(0x90000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: V1_0 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-invalid-source-encoding
  c include: ..\User\IC_Driver;..\Libraries\CMSIS;..\Libraries\Device;..\Libraries\StdPeriph_Driver\Inc;..\User;..\BSP;..\HMAC\inc;..\Internet\Application;..\Internet\MQTT;..\Internet\W5500;..\Internet\OTA;..\Mbedtls\library;..\Mbedtls\include\psa;..\Mbedtls\include\mbedtls;..\Mbedtls\my_aes_cbc;..\Menu;..\Internet\Shadow;..\Internet\ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x23000
  memory RVCT5: ROM 0x90000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Libraries/CMSIS
    ../Libraries/CMSIS/: core_cm33.h
  group Libraries/Device
    ../Libraries/Device/: f4_f3.h startup_f4_f3.s system_f4_f3.c system_f4_f3.h system_accelerate.lib
  group Libraries/StdPeriph_Driver
    ../Libraries/StdPeriph_Driver/Inc/: fxx_std.h
    ../Libraries/StdPeriph_Driver/Src/: fxx_eflash_ex.lib fxx_gpio.c fxx_rtc.c fxx_eflash.c fxx_uart.c fxx_spi.c fxx_tim.c
  group User
    ../User/: main.c fxx_it.c cloud_platform_para.c crc.c UserFunctionInterface.c LoopList.c
    ../Mbedtls/my_aes_cbc/: my_aes_cbc.c
  group Menu
    ../Menu/: menu.c menu_app.c menu_show.c
  group BSP
    ../BSP/: bsp_key.c bsp_usart1.c bsp_spi.c bsp_sdcard.c bsp_eflash.c bsp_uart_lcd.c bsp_timer7.c delay.c bsp_soft_spi.c bsp_usart3.c
  group Internet/W5500
    ../Internet/W5500/: socket.c w5500.c wizchip_conf.c
  group Internet/ESP8266
    ../Internet/ESP8266/: esp8266_config.c
  group Internet/Application
    ../Internet/Application/: dhcp.c dns.c mqtt_client.c tcp_client.c ssl_direct.c w5500_user_conf.c
  group Internet/MQTT
    ../Internet/MQTT/: mqtt_fun.c MQTTPacket.c MQTTSerializePublish.c MQTTConnectClient.c MQTTSubscribeClient.c
  group UserApplication
    ../Internet/OTA/: ota_firmware_updata.c handle_firmware.c
  group HMAC
    ../HMAC/scr/: utils_sha1.c utils_md5.c utils_hmac.c
  group Mbedtls
    ../Mbedtls/include/mbedtls/: config.h
    ../Mbedtls/library/: aes.c platform.c platform_util.c ssl_msg.c ssl_tls.c ssl_cli.c ssl_ciphersuites.c ctr_drbg.c debug.c entropy.c pk.c pk_wrap.c rsa.c rsa_internal.c bignum.c oid.c md.c md5.c sha256.c sha512.c sha1.c x509_crt.c x509.c asn1parse.c cipher.c cipher_wrap.c pkparse.c gcm.c
  group Readme
    ../: ReadMe.txt
