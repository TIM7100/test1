# Keil uVision project PRO.uvprojx, settings and files
target Recogner (6210000::V6.21::ARMCLANG)
  device: ACM32FP401RKU6 Aisinochip
  pack: Aisinochip.ACM32FP4.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) IROM2(0x90000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: PRO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3
  c misc: -Wno-invalid-source-encoding
  c include: .\Libraries\CMSIS;.\Libraries\Device;.\Libraries\StdPeriph_Driver\Inc;.\User;.\App;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x90000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\Objects\PRO.sct
  group Libraries/CMSIS
    ./Libraries/CMSIS/: core_cm33.h
  group Libraries/Device
    ./Libraries/Device/: f4_f3.h startup_f4_f3.s system_accelerate.lib system_f4_f3.c system_f4_f3.h
  group Libraries/StdPeriph_Driver
    ./Libraries/StdPeriph_Driver/Src/: fxx_eflash.c fxx_eflash_ex.lib fxx_gpio.c fxx_rtc.c fxx_tim.c fxx_uart.c fxx_i2c.c
    ./Libraries/StdPeriph_Driver/Inc/: fxx_std.h
  group User
    ./User/: main.c
  group App
    ./App/: uart.c delay.c
