# Keil uVision project ACH512.uvproj, settings and files
target project (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ACH512 +hex
  c flags: Optim=1 oTime=1
  c misc: --diag_suppress=1293,111,550
  c include: .\ACH512\driver;.\ACH512\system;.\APP;.\CMSIS\Include;.\COMMON;.\lcd;.\ExternalFlash;.\ExternalFlash\inc;.\Internet\W5500;.\Internet\Application;.\Internet\OTA;.\HMAC\inc;.\HMAC\scr;.\Internet\MQTT;.\Mbedtls\my_aes_ecb;.\Mbedtls\include\mbedtls;.\Mbedtls\include\psa;.\Mbedtls\include\mbedtls;.\Internet\Application;.\Menu;.\Internet\ESP8266
  memory RVCT4: ROM 0x0 size 0x2fe00
  memory RVCT9: RAM 0x20000040 size 0x1ffc0
  group system
    ./ACH512/system/: startup.s system_ach512.c
  group driver
    ./ACH512/driver/: uart.c delay.c eflash.c gpio.c rtc.c lcd.c
  group common
    ./COMMON/: common.c
  group app
    ./APP/: main.c app.c crc.c UserFunctionInterface.c cloud_platform_para.c LoopList.c
    ./Mbedtls/my_aes_ecb/: my_aes_ecb.c
  group doc
    ./: Abstratct.txt
  group lcd
    ./lcd/: cmd_queue.c hmi_driver.c use_lcd.c
  group ExternalFlash
    ./ExternalFlash/: ExternalFlash.c XxySpi.c
  group Internet/w5500
    ./Internet/W5500/: socket.c w5500.c wizchip_conf.c
  group Internet/Appliaction
    ./Internet/Application/: dhcp.c dns.c mqtt_client.c ssl_direct.c tcp_client.c w5500_user_conf.c
  group UserAppliaction
    ./Internet/OTA/: ota_firmware_handle.c ota_firmware_update.c
  group HMAC
    ./HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group Internet/MQTT
    ./Internet/MQTT/: cJSON.c mqtt_fun.c MQTTConnectClient.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c
  group Mbedtls
    ./Mbedtls/library/: aes.c asn1parse.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c debug.c entropy.c gcm.c md.c md5.c oid.c pk.c pk_wrap.c pkparse.c platform.c platform_util.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_ciphersuites.c ssl_cli.c ssl_msg.c ssl_tls.c x509.c x509_crt.c
    ./Mbedtls/include/mbedtls/: config.h
  group show
    ./Menu/: menu_show.c
  group Internet/ESP8266
    ./Internet/ESP8266/: esp8266_config.c
