# Keil uVision project ACH512.uvproj, settings and files
target project (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: IAP +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1
  c misc: --diag_suppress=1293,111,550
  c include: .\Driver\inc;.\System\inc;.\User\inc;.\UsbApp\inc;.\UserDriver\inc;.\AesEncDec\inc;.\ExternalFlash\inc;.\UsbApp\inc;.\Internet\W5500;.\Internet\Application;.\User;.\Internet\MQTT;.\Mbedtls\include\mbedtls;.\Mbedtls\include\psa;.\HMAC\inc;.\Mbedtls\include\mbedtls;.\Internet\OTA;.\Menu;.\Mbedtls\my_aes_ecb;.\WiFi;.\LCD
  memory RVCT4: ROM 0x0 size 0x2fe00
  memory RVCT9: RAM 0x20000040 size 0x1ffc0
  group System
    ./system/: startup.s system_ach512.c common.c
  group Driver
    ./Driver/: uart.c eflash.c lcd.c gpio.c delay.c rtc.c
  group User
    ./User/: main.c UserFunctionInterface.c cloud_platform_para.c crc.c LoopList.c
    ./Mbedtls/my_aes_ecb/: my_aes_ecb.c
  group ExternalFlash
    ./ExternalFlash/: XxySpi.c ExternalFlash.c
  group Menu
    ./Menu/: menu_show.c
  group Internet/w5500
    ./Internet/W5500/: socket.c w5500.c wizchip_conf.c
  group Internet/Appliaction
    ./Internet/Application/: w5500_user_conf.c dhcp.c dns.c tcp_client.c ssl_direct.c mqtt_client.c
  group Internet/MQTT
    ./Internet/MQTT/: mqtt_fun.c MQTTPacket.c MQTTSerializePublish.c MQTTConnectClient.c MQTTSubscribeClient.c cJSON.c
  group Mbedtls
    ./Mbedtls/library/: aes.c platform.c platform_util.c ssl_msg.c ssl_tls.c ssl_cli.c ssl_ciphersuites.c ctr_drbg.c debug.c entropy.c pk.c pk_wrap.c rsa.c rsa_internal.c bignum.c oid.c md.c md5.c sha256.c sha512.c sha1.c x509_crt.c x509.c asn1parse.c cipher_wrap.c pkparse.c gcm.c cipher.c
    ./Mbedtls/include/mbedtls/: config.h
  group HMAC
    ./HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group UserAppliaction
    ./Internet/OTA/: ota_firmware_update.c ota_firmware_handle.c
  group WiFi
    ./WiFi/: esp8266_config.c
  group LCD
    ./LCD/: cmd_queue.c hmi_driver.c use_lcd.c
