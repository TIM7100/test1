# Keil uVision project STM32_LineTest_MainBoard.uvproj, settings and files
target NPG83_MainBoard (ARM-ADS)
  device: STM32F103VG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NPG83_10P +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\CodeFile\CommonFunction\inc;..\CodeFile\MainSlave\inc;..\CodeFile\ScreenOS\inc;..\CodeFile\system\inc;..\CodeFile\UserFunction\inc;..\CodeFile\UserPeripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group system
    ./: startup_stm32f10x_xl.s
    ../CodeFile/system/src/: core_cm3.c misc.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c system_stm32f10x.c stm32f10x_usart.c stm32f10x_bkp.c
  group MainSlave
    ../CodeFile/MainSlave/: MainSlaveInterface.c
  group UserFunction
    ../CodeFile/UserFunction/: CheckFunction.c ClearFunction.c main.c menu.c UserFunctionInterface.c
  group CommonFunction
    ../CodeFile/CommonFunction/: CommonFunction.c crc.c
  group ScreenOS
    ../CodeFile/ScreenOS/: usart_lcd.c user_OS.c
  group UserPeripheral
    ../CodeFile/UserPeripheral/: flash.c rtc.c Timer0.c user_Peripheral.c user_system_init.c w25qxx.c Timer3.c
